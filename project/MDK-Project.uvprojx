# Keil uVision project MDK-Project.uvprojx, settings and files
target OBD-1939-Project (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDK-Project +hex
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\lib\inc;..\user;..\Source;..\Source\USB\config\include;..\Source\USB\lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../startup/: startup_stm32f10x_cl.s
  group Cmsis
    ../cmsis/: system_stm32f10x.c
  group Library
    ../lib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c
  group User
    ../user/: main.c stm32f10x_it.c include.h debug.h
  group Driver
    ../Source/Driver/: flash.c systick.c usart.c wdg.c timer.c can.c spi.c bsp.c
  group Public
    ../Source/Public/: public.c
  group OBD_1939
    ../Source/OBD_1939/: obd_1939.c
  group Peripheral
    ../Source/Peripheral/: gps.c w25x.c gprs.c
  group JTT808
    ../Source/JTT808/: jtt808.c jtt808_alarm_state.c jtt808_area.c jtt808_config.c jtt808_initiative_send.c jtt808_list_prc.c jtt808_location.c jtt808_param.c jtt808_point_in_polygon.c jtt808_rec.c
  group fatfs
    ../Source/fatfs/: diskio.c ff.c
  group Update
    ../Source/Update/: update.c
  group Common
    ../Source/Common/: common.c Config_Parameter.c
  group USB_Config
    ../Source/USB/config/source/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB_Lib
    ../Source/USB/lib/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
